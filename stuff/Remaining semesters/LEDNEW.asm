LIST P=16F877a
#include p16f877a.inc  
	BSF STATUS,RP0
	BCF STATUS,RP1
	MOVLW 0X00
	MOVWF TRISB
	BCF STATUS,RP0
	BCF STATUS,RP1
	LOOP:
	MOVLW 0XFF
	MOVWF PORTB
	CALL DELAY
	MOVLW 0X00
	MOVWF PORTB
	CALL DELAY
	GOTO LOOP
	DELAY:
	MOVLW 0X05
	MOVWF 0X30
	LABEL1:
	MOVLW 0XFF
	MOVWF 0X31
	LABEL2:
			MOVLW 0XFF
			MOVWF 0X32
	LABEL3:
			DECFSZ 0X32,F
			GOTO LABEL3
			DECFSZ 0X31,F
			GOTO LABEL2
			DECFSZ 0X30,F
			GOTO LABEL1
			RETURN 
	END
	
