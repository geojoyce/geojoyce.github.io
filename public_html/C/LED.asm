LIST P= 16f877a
#INCLUDE P16F877A.INC

NEXT:
BCF STATUS,RP1
BSF STATUS,RP0
CLRF TRISB
BCF STATUS,RP0
MOVLW 0XFF
MOVWF PORTB
CALL DELAY
CLRF PORTB
CALL DELAY
GOTO NEXT
DELAY:

  MOVLW 0X05
  MOVWF 0X20

 LOOP2:
  MOVLW 0XFF
  MOVWF 0X21
 LOOP1:
  MOVLW 0XFF
  MOVWF 0X22
 LOOP:
  DECFSZ 0X22,1
  GOTO LOOP
  DECFSZ 0X22,1
  GOTO LOOP1
  DECFSZ 0X20,1
  GOTO LOOP2
  RETURN
END
